Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: Betobord L.ifc
Time: 2026-08-14T10:00:24
Author: Szücs Attila
Organization: No Organization
Written by: ODA SDAI 23.9
Authorization: apack

# IfcBuildingStorey, IFC export
In: Épület
Elevation: 0 m

# IfcAnnotation (96)
In: IFC export
Name
67 x 
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000247; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000009; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000248; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000249; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000053; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000073; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000090; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000091; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000092; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000093; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000094; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000095; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000096; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000099; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000100; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000101; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000008; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000072; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000027; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000034; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000035; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000097; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000098; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000231; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000232; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000233; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000234; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000259; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0022BőE0000000074; Elszámolásmód: db; Objektumnév: Bővített elem

# IfcBuildingElementProxy (3)
In: IFC export
Material: cementkötésű faforgácslap
AllplanAttributes - Státusz: Újépítés; Szakma: Betonmunka; V6: 0.01 m; V7: 1.25 m; Sraffozás_kitöltés: 22; Objektumnév: bentmaradó zsaluzat; Anyag: cementkötésű faforgácslap; Teherhordó építőelem: no; Típus: Betobord L; Elszámolásmód: m
Pset_ManufacturerTypeInformation - Manufacturer: BAU-HAUS Kft.
Name | V8 (m) | Név | Statikai pozíció - felhasználói megadás | Allright_építőelem_ID | ArticleNumber
Betobord L 20 | 0.2 | Betobord L 20 | BL-01 | 0022BőE0000000115 | BL20
Betobord L 25 | 0.25 | Betobord L 25 | BL-02 | 0022BőE0000000197 | BL25
Betobord L 30 | 0.3 | Betobord L 30 | BL-03 | 0022BőE0000000199 | BL30

# IfcElementAssembly (5)
In: IFC export
AllplanAttributes - Elszámolásmód: db; Objektumnév: Elemcsoport
Name | Allright_építőelem_ID
 | 0022Ecs0000000174
 | 0022Ecs0000000175
 | 0022Ecs0000000228
 | 0022Ecs0000000229
 | 0022Ecs0000000230
