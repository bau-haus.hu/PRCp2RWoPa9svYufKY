Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: Betobeam.ifc
Time: 2026-08-14T10:01:48
Author: Szücs Attila
Organization: No Organization
Written by: ODA SDAI 23.9
Authorization: apack

# IfcBuildingStorey, IFC export
In: Épület
Elevation: 0 m

# IfcBuildingElementProxy (21)
In: IFC export
Material: cementkötésű faforgácslap
AllplanAttributes - Státusz: Újépítés; Szakma: Betonmunka; V6: 0.01 m; V7: 1.25 m; Sraffozás_kitöltés: 22; Objektumnév: bentmaradó zsaluzat; Anyag: cementkötésű faforgácslap; Teherhordó építőelem: no; Típus: -; Válasz 1: -; Elszámolásmód: m
Pset_ManufacturerTypeInformation - ArticleNumber: -; Manufacturer: BAU-HAUS Kft.
Name | V8 (m) | Név | Statikai pozíció - felhasználói megadás | Vastagság, készelem [cm] (m) | Dimenzió1 | Dimenzió2 | Allright_építőelem_ID
Betobeam MG magasgerenda | 0.4 | Betobeam MG magasgerenda | MG-01 | 0.25 | 0 | 0 | 0027BőE0000006410
Betobeam MG magasgerenda | 0.5 | Betobeam MG magasgerenda | MG-02 | 0.3 | 0 | 0 | 0027BőE0000006411
Betobeam MG magasgerenda | 0.6 | Betobeam MG magasgerenda | MG-03 | 0.38 | 0 | 0 | 0027BőE0000006412
Betobeam PG peremgerenda | 0.55 | Betobeam PG peremgerenda | MG-04 | 0.25 | 10 | 25 | 0027BőE0000006413
Betobeam PG peremgerenda | 0.55 | Betobeam PG peremgerenda | MG-05 | 0.3 | 10 | 25 | 0027BőE0000006414
Betobeam PG peremgerenda | 0.55 | Betobeam PG peremgerenda | MG-06 | 0.38 | 10 | 25 | 0027BőE0000006415
Betobeam AT attika | 0.45 | Betobeam AT attika | AT-1 | 0.25 | 25 | 0 | 0027BőE0000006416
Betobeam AT attika | 0.45 | Betobeam AT attika | AT-2 | 0.3 | 25 | 0 | 0027BőE0000006417
Betobeam AT attika | 0.45 | Betobeam AT attika | AT-3 | 0.38 | 25 | 0 | 0027BőE0000006418
Betobeam ABE alulborda előregyártott | 0.45 | Betobeam ABE alulborda előregyártott | ABE-01 | 0.25 | 25 | 0 | 0027BőE0000006419
Betobeam ABE alulborda előregyártott | 0.45 | Betobeam ABE alulborda előregyártott | ABE-02 | 0.3 | 25 | 0 | 0027BőE0000006420
Betobeam ABE alulborda előregyártott | 0.45 | Betobeam ABE alulborda előregyártott | ABE-03 | 0.38 | 25 | 0 | 0027BőE0000006421
Betobeam ABM alulborda monolit | 0.45 | Betobeam ABM alulborda monolit | ABM-01 | 0.25 | 25 | 0 | 0027BőE0000006422
Betobeam ABM alulborda monolit | 0.45 | Betobeam ABM alulborda monolit | ABM-02 | 0.3 | 25 | 0 | 0027BőE0000006423
Betobeam ABM alulborda monolit | 0.45 | Betobeam ABM alulborda monolit | ABM-03 | 0.38 | 25 | 0 | 0027BőE0000006424
Betobeam FB felülborda | 0.45 | Betobeam FB felülborda | FB-01 | 0.25 | 20 | 25 | 0027BőE0000006425
Betobeam FB felülborda | 0.45 | Betobeam FB felülborda | FB-02 | 0.3 | 20 | 25 | 0027BőE0000006426
Betobeam FB felülborda | 0.45 | Betobeam FB felülborda | FB-03 | 0.38 | 20 | 25 | 0027BőE0000006427
Betobeam SV szintváltás | 0.5 | Betobeam SV szintváltás | SV-01 | 0.25 | 20 | 30 | 0027BőE0000006428
Betobeam SV szintváltás | 0.5 | Betobeam SV szintváltás | SV-02 | 0.3 | 20 | 30 | 0027BőE0000006429
Betobeam SV szintváltás | 0.5 | Betobeam SV szintváltás | SV-03 | 0.38 | 20 | 30 | 0027BőE0000006430

# IfcElementAssembly (28)
In: IFC export
AllplanAttributes - Elszámolásmód: db; Objektumnév: Elemcsoport
Name | Allright_építőelem_ID
 | 0027Ecs0000005796
 | 0027Ecs0000005819
 | 0027Ecs0000005842
 | 0027Ecs0000005899
 | 0027Ecs0000005925
 | 0027Ecs0000005951
 | 0027Ecs0000005992
 | 0027Ecs0000006015
 | 0027Ecs0000006038
 | 0027Ecs0000006079
 | 0027Ecs0000006102
 | 0027Ecs0000006125
 | 0027Ecs0000006166
 | 0027Ecs0000006189
 | 0027Ecs0000006212
 | 0027Ecs0000006260
 | 0027Ecs0000006284
 | 0027Ecs0000006308
 | 0027Ecs0000006356
 | 0027Ecs0000006380
 | 0027Ecs0000006404
 | 0027Ecs0000006862
 | 0027Ecs0000007283
 | 0027Ecs0000007674
 | 0027Ecs0000008019
 | 0027Ecs0000008435
 | 0027Ecs0000008886
 | 0027Ecs0000009237
