Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: Thermoring.ifc
Time: 2026-08-14T10:01:34
Author: Szücs Attila
Organization: No Organization
Written by: ODA SDAI 23.9
Authorization: apack

# IfcBuildingStorey, IFC export
In: Épület
Elevation: 0 m

# IfcBuildingElementProxy (9)
In: IFC export
Material: cementkötésű faforgácslap
AllplanAttributes - Státusz: Újépítés; Szakma: Betonmunka; V6: 0.01 m; V7: 1.25 m; Objektumnév: bentmaradó zsaluzat; Anyag: cementkötésű faforgácslap; Teherhordó építőelem: no; Típus: Thermoring
Pset_ManufacturerTypeInformation - Manufacturer: BAU-HAUS Kft.
Name | V8 (m) | Név | Statikai pozíció - felhasználói megadás | Vastagság, készelem [cm] (m) | Allright_építőelem_ID | Elszámolásmód | ArticleNumber | Sraffozás_kitöltés
Thermoring 30/20 cm | 0.2 | Thermoring 30/20 cm | TR-01 | 0.3 | 0026BőE0000002443 | m3 | TR3020 | AllplanAttributes - Rétegvastagság: 0.05 m; Tűzvédelmi osztály: E
Thermoring 30/25 cm | 0.25 | Thermoring 30/25 cm | TR-02 | 0.3 | 0026BőE0000002444 | m | TR3025 | 22
Thermoring 30/30 cm | 0.3 | Thermoring 30/30 cm | TR-03 | 0.3 | 0026BőE0000002445 | m | TR3030 | 22
Thermoring 38/20 cm | 0.2 | Thermoring 38/20 cm | TR-04 | 0.2 | 0026BőE0000002446 | m | TR3820 | 22
Thermoring 38/25 cm | 0.25 | Thermoring 38/25 cm | TR-05 | 0.38 | 0026BőE0000002447 | m | TR3825 | 22
Thermoring 38/30 cm | 0.3 | Thermoring 38/30 cm | TR-06 | 0.38 | 0026BőE0000002448 | m | TR3830 | 22
Thermoring 44/20 cm | 0.2 | Thermoring 44/20 cm | TR-07 | 0.44 | 0026BőE0000002449 | m | TR4420 | 22
Thermoring 44/25 cm | 0.25 | Thermoring 44/25 cm | TR-08 | 0.44 | 0026BőE0000002450 | m | TR4425 | 22
Thermoring 44/30 cm | 0.3 | Thermoring 44/30 cm | TR-09 | 0.44 | 0026BőE0000002451 | m | TR4430 | 22

# IfcElementAssembly (11)
In: IFC export
AllplanAttributes - Elszámolásmód: db; Objektumnév: Elemcsoport
Name | Allright_építőelem_ID
 | 0026Ecs0000002473
 | 0026Ecs0000002495
 | 0026Ecs0000002517
 | 0026Ecs0000002539
 | 0026Ecs0000002561
 | 0026Ecs0000002583
 | 0026Ecs0000002605
 | 0026Ecs0000002627
 | 0026Ecs0000002649
 | 0026Ecs0000002887
 | 0026Ecs0000003125
