Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: Betobord LS.ifc
Time: 2026-08-14T10:00:48
Author: Szücs Attila
Organization: No Organization
Written by: ODA SDAI 23.9
Authorization: apack

# IfcBuildingStorey, IFC export
In: Épület
Elevation: 0 m

# IfcBuildingElementProxy (7)
In: IFC export
Material: cementkötésű faforgácslap
AllplanAttributes - Státusz: Újépítés; Szakma: Betonmunka; V6: 0.01 m; V7: 1.25 m; Sraffozás_kitöltés: 22; Objektumnév: bentmaradó zsaluzat; Anyag: cementkötésű faforgácslap; Teherhordó építőelem: no; Típus: Betobord LS; Elszámolásmód: m
Pset_ManufacturerTypeInformation - Manufacturer: BAU-HAUS Kft.
Name | V8 (m) | Név | Statikai pozíció - felhasználói megadás | Allright_építőelem_ID | ArticleNumber
Betobord LS rögzítőlábakkal 16cm | 0.16 | Betobord LS rögzítőlábakkal 16cm | BLS-01 | 0023BőE0000001247 | BZPBBLSZ16-X
Betobord LS rögzítőlábakkal 18cm | 0.18 | Betobord LS rögzítőlábakkal 18cm | BLS-02 | 0023BőE0000001248 | BZPBBLSZ18-X
Betobord LS rögzítőlábakkal 20cm | 0.2 | Betobord LS rögzítőlábakkal 20cm | BLS-03 | 0023BőE0000001249 | BZPBBLSZ20-X
Betobord LS rögzítőlábakkal 25cm | 0.25 | Betobord LS rögzítőlábakkal 25cm | BLS-04 | 0023BőE0000001250 | BZPBBLSZ25-X
Betobord LS rögzítőlábakkal 30cm | 0.3 | Betobord LS rögzítőlábakkal 30cm | BLS-05 | 0023BőE0000001251 | BZPBBLSZ30-X
Betobord LS rögzítőlábakkal 35cm | 0.35 | Betobord LS rögzítőlábakkal 35cm | BLS-06 | 0023BőE0000001252 | BZPBBLSZ35-X
Betobord LS rögzítőlábakkal 40cm | 0.4 | Betobord LS rögzítőlábakkal 40cm | BLS-07 | 0023BőE0000001253 | BZPBBLSZ40-X

# IfcElementAssembly (9)
In: IFC export
AllplanAttributes - Elszámolásmód: db; Objektumnév: Elemcsoport
Name | Allright_építőelem_ID
 | 0023Ecs0000001179
 | 0023Ecs0000001189
 | 0023Ecs0000001199
 | 0023Ecs0000001209
 | 0023Ecs0000001219
 | 0023Ecs0000001229
 | 0023Ecs0000001239
 | 0023Ecs0000001432
 | 0023Ecs0000001611
