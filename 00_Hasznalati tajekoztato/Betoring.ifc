Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: Betoring.ifc
Time: 2026-08-14T10:01:20
Author: Szücs Attila
Organization: No Organization
Written by: ODA SDAI 23.9
Authorization: apack

# IfcBuildingStorey, IFC export
In: Épület
Elevation: 0 m

# IfcBuildingElementProxy (9)
In: IFC export
Material: cementkötésű faforgácslap
AllplanAttributes - Státusz: Újépítés; Szakma: Betonmunka; V6: 0.01 m; V7: 1.25 m; Sraffozás_kitöltés: 22; Objektumnév: bentmaradó zsaluzat; Anyag: cementkötésű faforgácslap; Teherhordó építőelem: no; Típus: Betoring; Elszámolásmód: m
Pset_ManufacturerTypeInformation - Manufacturer: BAU-HAUS Kft.
Name | V8 (m) | Név | Statikai pozíció - felhasználói megadás | Vastagság, készelem [cm] (m) | Allright_építőelem_ID | ArticleNumber
Betoring 25/20 cm | 0.2 | Betoring 25/20 cm | BR-01 | 0.25 | 0025BőE0000001814 | BR2520
Betoring 25/25 cm | 0.25 | Betoring 25/25 cm | BR-02 | 0.25 | 0025BőE0000001815 | BR2525
Betoring 25/30 cm | 0.3 | Betoring 25/30 cm | BR-03 | 0.25 | 0025BőE0000001816 | BR2530
Betoring 30/20 cm | 0.2 | Betoring 30/20 cm | BR-04 | 0.3 | 0025BőE0000001817 | BR3020
Betoring 30/25 cm | 0.25 | Betoring 30/25 cm | BR-05 | 0.3 | 0025BőE0000001818 | BR3025
Betoring 30/30 cm | 0.3 | Betoring 30/30 cm | BR-06 | 0.3 | 0025BőE0000001819 | BR3030
Betoring 38/20 cm | 0.2 | Betoring 38/20 cm | BR-07 | 0.38 | 0025BőE0000001820 | BR3820
Betoring 38/25 cm | 0.25 | Betoring 38/25 cm | BR-08 | 0.38 | 0025BőE0000001821 | BR3825
Betoring 38/30 cm | 0.3 | Betoring 38/30 cm | BR-09 | 0.38 | 0025BőE0000001822 | BR3830

# IfcElementAssembly (11)
In: IFC export
AllplanAttributes - Elszámolásmód: db; Objektumnév: Elemcsoport
Name | Allright_építőelem_ID
 | 0025Ecs0000001675
 | 0025Ecs0000001690
 | 0025Ecs0000001705
 | 0025Ecs0000001720
 | 0025Ecs0000001735
 | 0025Ecs0000001750
 | 0025Ecs0000001765
 | 0025Ecs0000001780
 | 0025Ecs0000001795
 | 0025Ecs0000002055
 | 0025Ecs0000002288
