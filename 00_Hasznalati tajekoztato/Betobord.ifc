Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: Betobord.ifc
Time: 2026-08-14T10:00:02
Author: Szücs Attila
Organization: No Organization
Written by: ODA SDAI 23.9
Authorization: apack

# IfcBuildingStorey, IFC export
In: Épület
Elevation: 0 m

# IfcAnnotation (88)
In: IFC export
Name
54 x 
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001395; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001396; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000000387; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000000016; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000000017; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001397; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000000846; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000000860; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001398; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001399; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001083; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001084; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001097; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001112; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001135; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001156; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001157; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001153; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001159; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001160; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001152; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001162; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001164; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001161; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001166; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001167; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001168; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001169; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001195; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001196; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001197; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001198; Elszámolásmód: m; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001406; Elszámolásmód: db; Objektumnév: Bővített elem
 | AllplanAttributes - Allright_építőelem_ID: 0021BőE0000001170; Elszámolásmód: db; Objektumnév: Bővített elem

# IfcBuildingElementProxy (6)
In: IFC export
Material: cementkötésű faforgácslap
AllplanAttributes - Státusz: Újépítés; Szakma: Betonmunka; V7: 1.6 m; Sraffozás_kitöltés: 22; Objektumnév: bentmaradó zsaluzat; Anyag: cementkötésű faforgácslap; Teherhordó építőelem: no; Típus: Betobord; Elszámolásmód: m
Pset_ManufacturerTypeInformation - Manufacturer: BAU-HAUS Kft.
Name | V6 (m) | V8 (m) | Név | Statikai pozíció - felhasználói megadás | Allright_építőelem_ID | ArticleNumber
Betobord zsaluzóelem 30 | 0.01 | 0.3 | Betobord zsaluzóelem 30 | BB-01 | 0021BőE0000001212 | BB30
Betobord zsaluzóelem 40 | 0.01 | 0.4 | Betobord zsaluzóelem 40 | BB-02 | 0021BőE0000001213 | BB40
Betobord zsaluzóelem 50 | 0.01 | 0.5 | Betobord zsaluzóelem 50 | BB-03 | 0021BőE0000001214 | BB50
Betobord zsaluzóelem 30 (v= 14mm) | 0.014 | 0.3 | Betobord zsaluzóelem 30 (v= 14mm) | BB-04 | 0021BőE0000001215 | BB30
Betobord zsaluzóelem 40 (v= 14mm) | 0.014 | 0.4 | Betobord zsaluzóelem 40 (v= 14mm) | BB-05 | 0021BőE0000001216 | BB40
Betobord zsaluzóelem 50 (v= 14mm) | 0.014 | 0.5 | Betobord zsaluzóelem 50 (v= 14mm) | BB-06 | 0021BőE0000001217 | BB50

# IfcElementAssembly (8)
In: IFC export
AllplanAttributes - Elszámolásmód: db; Objektumnév: Elemcsoport
Name | Allright_építőelem_ID
 | 0021Ecs0000001193
 | 0021Ecs0000001194
 | 0021Ecs0000000845
 | 0021Ecs0000000859
 | 0021Ecs0000000873
 | 0021Ecs0000001082
 | 0021Ecs0000001096
 | 0021Ecs0000001090
