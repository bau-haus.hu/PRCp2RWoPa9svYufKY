Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: Thermobord.ifc
Time: 2026-08-14T10:01:04
Author: Szücs Attila
Organization: No Organization
Written by: ODA SDAI 23.9
Authorization: apack

# IfcBuildingStorey, IFC export
In: Épület
Elevation: 0 m

# IfcBuildingElementProxy (6)
In: IFC export
Material: cementkötésű faforgácslap
AllplanAttributes - Státusz: Újépítés; Szakma: Betonmunka; Rétegvastagság: 0.05 m; V6: 0.05 m; V7: 1.25 m; Sraffozás_kitöltés: 22; Objektumnév: bentmaradó zsaluzat; Anyag: cementkötésű faforgácslap; Teherhordó építőelem: no; Típus: Thermobord; Tűzvédelmi osztály: E; Elszámolásmód: m
Pset_ManufacturerTypeInformation - Manufacturer: BAU-HAUS Kft.
Name | V8 (m) | Név | Statikai pozíció - felhasználói megadás | Allright_építőelem_ID | ArticleNumber
Thermobord X 20cm | 0.2 | Thermobord X 20cm | TH-01 | 0024BőE0000001274 | BZPTB20-000X
Thermobord X 22cm | 0.22 | Thermobord X 22cm | TH-02 | 0024BőE0000001275 | BZPTB22-000X
Thermobord X 25cm | 0.25 | Thermobord X 25cm | TH-03 | 0024BőE0000001276 | BZPTB25-000X
Thermobord X 30cm | 0.3 | Thermobord X 30cm | TH-04 | 0024BőE0000001277 | BZPTB30-000X
Thermobord X 35cm | 0.35 | Thermobord X 35cm | TH-05 | 0024BőE0000001278 | BZPTB35-000X
Thermobord X 40cm | 0.4 | Thermobord X 40cm | TH-06 | 0024BőE0000001279 | BZPTB40-000X

# IfcElementAssembly (8)
In: IFC export
AllplanAttributes - Elszámolásmód: db; Objektumnév: Elemcsoport
Name | Allright_építőelem_ID
 | 0024Ecs0000001166
 | 0024Ecs0000001200
 | 0024Ecs0000001227
 | 0024Ecs0000001236
 | 0024Ecs0000001244
 | 0024Ecs0000001252
 | 0024Ecs0000001260
 | 0024Ecs0000001268
